# Keil uVision project EC_Praktikum.uvproj, settings and files
target Target 1 (166/167)
  device: C167CR-LM Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xE000-0xE7FF) ICAN(0xE800-0xEFFF) CLOCK(20000000) MOD167
  output: 09A8xx
  group Source Group 1
    ./: VORLAGE.C
